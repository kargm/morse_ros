Commit message: extended urdf for visualization

File: kitchen_data_player/urdfs/objects_big.urdf (robot description, URDF)
Before this commit: robot myfirst, 6 links, 5 joints
Joints:
- joint cupboard0_table: child cupboard_0 -> cupboard0
