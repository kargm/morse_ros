Commit message: Refined objects

File: kitchen_data_player/urdfs/objects.urdf (robot description, URDF)
Before this commit: robot myfirst, 4 links, 3 joints
Links:
- link drawer: geometry visual box size=0.564 0.51 0.01
